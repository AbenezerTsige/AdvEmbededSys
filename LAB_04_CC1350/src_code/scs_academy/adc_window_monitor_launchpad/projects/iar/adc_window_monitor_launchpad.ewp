# IAR project adc_window_monitor_launchpad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEVICE_FAMILY=cc13x0; DeviceFamily_CC13X0
  ICCARM.CCIncludePath2: C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_window_monitor_launchpad.srec
  ILINK.IlinkOutputFile: adc_window_monitor_launchpad.out
  ILINK.IlinkAdditionalLibs: C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\devices\cc13x0\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_none.h main.c
  group sdk_files__do_not_edit
    C:/ti/simplelink_cc13x0_sdk_2_30_00_20/source/ti/devices/cc13x0/startup_files/: startup_iar.c ccfg.c
